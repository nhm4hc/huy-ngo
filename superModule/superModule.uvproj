# Keil uVision project superModule.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: superModule +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c displayLCD.c displayLCD.h LCD1602.c LCD1602.h module_1.c module_1.h module_2.c module_2.h i2c.c i2c.h module_7.c module_7.h module_8.c module_8.h module_9.c module_9.h module_11.c module_11.h intrins.h module_12.c module_12.h module_15.c module_15.h
