# Keil uVision project superModule_interrupt.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: superModule_interrupt +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c displayLCD.c displayLCD.h LCD1602.c LCD1602.h interruptPublish.c interruptPublish.h module_1.c module_1.h module_2.c module_2.h intrins.h module_5.c module_5.h
